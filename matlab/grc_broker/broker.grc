options:
  parameters:
    generate_options: qt_gui
    id: broker
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 3.84e6
  states: {}
- name: srs_enb1_tx_sock
  id: variable
  parameters:
    value: '"tcp://127.0.0.1:2000"'
  states: {}
- name: srs_enb1_tx_sock_proxy
  id: variable
  parameters:
    value: '"tcp://127.0.0.1:2100"'
  states: {}
- name: srs_ue1_tx_sock
  id: variable
  parameters:
    value: '"tcp://127.0.0.1:2001"'
  states: {}
- name: srs_ue1_tx_sock_proxy
  id: variable
  parameters:
    value: '"tcp://127.0.0.1:2101"'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/dmoskovskikh/devel/srsENB_signal_time_domain.dat
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '512'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: zeromq_rep_sink_0
  id: zeromq_rep_sink
  parameters:
    address: srs_enb1_tx_sock_proxy
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_0_0
  id: zeromq_rep_sink
  parameters:
    address: srs_ue1_tx_sock_proxy
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: srs_enb1_tx_sock
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0_0
  id: zeromq_req_source
  parameters:
    address: srs_ue1_tx_sock
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_throttle2_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle2_0, '0', qtgui_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_throttle2_0, '0', zeromq_rep_sink_0, '0']
- [blocks_throttle2_0_0, '0', zeromq_rep_sink_0_0, '0']
- [zeromq_req_source_0, '0', blocks_throttle2_0, '0']
- [zeromq_req_source_0_0, '0', blocks_throttle2_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
